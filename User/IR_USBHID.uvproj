# Keil uVision project IR_USBHID.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: CH552E_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Public;.\HardWare\GPIO;.\HardWare\TouchKey;.\HardWare\PWM;..\HardWare\USBComposite;..\HardWare\IR
  group Start
    ./: STARTUP.A51
  group HardWare
    ../HardWare/USBComposite/: USBComposite.C
    ../HardWare/IR/: timer.C
  group User
    ./: Main.C includes.h
  group Public
    ../Public/: Debug.C
